# IAR project Plasma.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: Libraries
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Emitterqualifier.srec
  ILINK.IlinkOutputFile: Emitterqualifier.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    Libraries/: eeprom.c stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_usart.c
    ./: Functions.c global_vars.c Interrupts.c main.c Setup.c Switch.c Uart.c
